# Autodesk Inventor assembly: 21.1169_9 ROD GUIDE 24
## iProperties
Created: 2011-02
Part Number: 21.1169_9 ROD GUIDE 24
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
