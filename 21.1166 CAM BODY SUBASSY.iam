# Autodesk Inventor assembly: 21.1166 CAM BODY SUBASSY
## iProperties
Created: 2007-03
Part Number: 21.1166 CAM BODY SUBASSY
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
